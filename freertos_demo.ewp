# IAR project freertos_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; C:\ti\TivaWare_C_Series-2.1.4.178; C:\ti\TivaWare_C_Series-2.1.4.178\third_party; C:\ti\TivaWare_C_Series-2.1.4.178\third_party\FreeRTOS; C:\ti\TivaWare_C_Series-2.1.4.178\third_party\FreeRTOS\Source\include; C:\ti\TivaWare_C_Series-2.1.4.178\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkIcfFile: freertos_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../../ti/TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../../ti/TivaWare_C_Series-2.1.4.178/examples/boards/ek-tm4c123gxl/drivers/: buttons.c rgb.c
    ./: freertos_demo.c led_task.c startup_ewarm.c switch_task.c
    ../../../../../ti/TivaWare_C_Series-2.1.4.178/third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../ti/TivaWare_C_Series-2.1.4.178/third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../../ti/TivaWare_C_Series-2.1.4.178/third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c ustdlib.c
